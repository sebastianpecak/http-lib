LOAD 0x70A80040 {
  CODE +0 {
    *(.0_vrx_hdr,+FIRST)
    *(+RO)
  }
  DATA +0 {
    *(.dummy_pdt,+FIRST)
    *(+RW)
}
  BSS +0 {
    *(+ZI)
  }
}
